# Keil uVision project LeArm.uvprojx, settings and files
target LeArm (6240000::V6.24::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: LeArm +hex
  AfterMake: fromelf.exe --bin --output="$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hiwonder/Peripherals/Inc;../Hiwonder;../Hiwonder/Portings/Inc;../Hiwonder/Arm/Inc;../Hiwonder/Middlewares/Inc;../Hiwonder/Chassis/Inc;../Hiwonder/Third_Party/U8g2;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1bc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: LeArm\LeArm.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: boot_entry.c RobotProtocol.c SafetyManager.c RobotSafety.c RobotRtos.c ChassisController.c SerialTransport.c RobotHealth.c RobotHealthWire.c ArmTask.c ChassisTask.c DefaultTask.c HealthTask.c SerialTask.c main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hiwonder/Peripherals
    ../Hiwonder/Peripherals/Src/: pwm_servos.c led.c w25q64.c ultrasound.c buzzer.c oled.c wonder_echo.c qmi8658.c stepper_strip.c serial_servo.c wonder_mv.c motor_module.c avoid_obstacles.c touch.c adc_sample.c
  group Hiwonder/Portings
    ../Hiwonder/Portings/Src/: led_porting.c ps2_porting.c pwm_servo_porting.c app_porting.c
  group Hiwonder/Arm
    ../Hiwonder/Arm/src/: robot_arm.c LeArm.lib
  group Hiwonder/Middleware
    ../Hiwonder/Middlewares/Src/: lwrb.c
  group Hiwonder/Chassis
    ../Hiwonder/Chassis/Src/: differential_chassis.c mecanum_chassis.c
  group Third_Party/U8g2
    ../Hiwonder/Third_Party/U8g2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_stdio.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group Application/User/Inc
    ../Core/Inc/: adc.h ArmTask.h boot_entry.h RobotTypes.h RobotProtocol.h SafetyManager.h RobotSafety.h RobotRtos.h ChassisController.h SerialTransport.h RobotHealth.h ChassisTask.h DefaultTask.h dma.h FreeRTOSConfig.h gpio.h HealthTask.h i2c.h main.h SerialTask.h spi.h stm32f1xx_hal_conf.h stm32f1xx_it.h tim.h usart.h
software components: CMSIS:CORE 6.1.1, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
